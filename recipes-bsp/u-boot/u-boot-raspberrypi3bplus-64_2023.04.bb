#
# Copyright (c) Cybertrust Japan Co., Ltd.
#
# SPDX-License-Identifier: MIT
#

require recipes-bsp/u-boot/u-boot-${PV}.inc
