FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += " \
   file://0020-configure.ac-setup.py-do-not-add-a-curses-include-pa.patch \
"
