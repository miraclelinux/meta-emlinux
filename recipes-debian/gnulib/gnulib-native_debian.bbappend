CVE_VERSION = "${@d.getVar('PV')[:4] + '-' + d.getVar('PV')[4:6] + '-' + d.getVar('PV')[6:8]}"
