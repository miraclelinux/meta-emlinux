RDEPENDS_${PN}-ptest_remove = " linux-libc-headers-base-dev"
RDEPENDS_${PN}-ptest_append = " linux-libc-headers-dev"
