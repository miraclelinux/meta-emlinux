CVE_VERSION = "${@d.getVar("PV").split('+')[0]}"
