FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://Fix-install-shared-so-target-s-dependency.patch"
