SRC_URI_append_ek874 = " \
	file://0001-Revert-rtc-interface-Fix-long-standing-race-when-set.patch \
"
