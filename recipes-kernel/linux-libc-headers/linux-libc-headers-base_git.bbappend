# Use linux kernel major and minor version instead of git revision.
PV = "4.19"
